# Keil uVision project Final_Project_2DX3.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Final_Project_2DX3
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: PLL_Emily.c SysTick_Emily.c I2C0.c uart.c onboardLEDs.c VL53L1X_api.c motor_control.c vl53l1_platform_2dx4.c main.c
software components: CMSIS:CORE 6.1.0, Device:Startup 3.2.3
